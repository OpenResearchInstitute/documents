options:
  parameters:
    author: rob + kb5mu
    generate_options: qt_gui
    id: M17_upsim_3_pfb
    output_language: python
    title: M17 Multi-Uplink Simulation
  states: {}

blocks:
- name: chan_spacing
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    comment: used by m17-mod
    value: '10'
  states: {}
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: tx_freq - 10000
    step: '100'
    stop: tx_freq + 10000
    value: tx_freq + freq_correction
  states: {}
- name: n_chans
  id: variable
  parameters:
    value: '9'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: in m17-mod output
    value: symbol_rate * interpolation_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: M17 Symbol Rate
    value: '4800'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (chan_spacing/2)
    gain: '1.0'
    samp_rate: (n_chans+1)*chan_spacing
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '441500000'
  states: {}
- name: tx_rate
  id: variable
  parameters:
    comment: out to SDR
    value: '2000000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_1_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_2
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1_2_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ssf081_01.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ssf081_02.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: ssf081_03.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: ssf081_04.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_0_0
  id: blocks_file_source
  parameters:
    file: ssf081_07.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_1
  id: blocks_file_source
  parameters:
    file: ssf081_05.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_1_0
  id: blocks_file_source
  parameters:
    file: ssf081_08.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_2
  id: blocks_file_source
  parameters:
    file: ssf081_06.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1_2_0
  id: blocks_file_source
  parameters:
    file: ssf081_09.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: |-
      Fills the half-channel
      at the top and bottom
      of the band with zero.
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_0_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_1
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_1_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_2
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1_2_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    bandwidth: '200000'
    buffer_size: 2**20
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lo_freq
    samplerate: tx_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import fractions
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[]'
    connections: n_chans+1
    numchans: n_chans+1
    taps: taps
    twox: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: (n_chans+1)*chan_spacing
    fc: '0'
    fftsize: '1024'
    name: '"Transmitted Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Frequency Modulation Data (Center Channel)"'
    size: '1024'
    srate: sample_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: fractions.Fraction(tx_rate, (n_chans+1)*chan_spacing).denominator
    fbw: '0.4'
    interp: fractions.Fraction(tx_rate, (n_chans+1)*chan_spacing).numerator
    type: ccf
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_1
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_1_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_2
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0_2_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_1
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz in, 12.5 kHz out
    decim: fractions.Fraction(chan_spacing, sample_rate).denominator
    fbw: '0.4'
    interp: fractions.Fraction(chan_spacing, sample_rate).numerator
    type: ccc
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_3, '0']
- [analog_frequency_modulator_fc_0_0, '0', rational_resampler_xxx_3_1, '0']
- [analog_frequency_modulator_fc_0_1, '0', rational_resampler_xxx_3_0, '0']
- [analog_frequency_modulator_fc_0_1_0, '0', rational_resampler_xxx_3_0_0, '0']
- [analog_frequency_modulator_fc_0_1_0_0, '0', rational_resampler_xxx_3_0_0_0, '0']
- [analog_frequency_modulator_fc_0_1_1, '0', rational_resampler_xxx_3_0_1, '0']
- [analog_frequency_modulator_fc_0_1_1_0, '0', rational_resampler_xxx_3_0_1_0, '0']
- [analog_frequency_modulator_fc_0_1_2, '0', rational_resampler_xxx_3_0_2, '0']
- [analog_frequency_modulator_fc_0_1_2_0, '0', rational_resampler_xxx_3_0_2_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_short_to_float_0_1, '0']
- [blocks_file_source_0_1_0, '0', blocks_short_to_float_0_1_0, '0']
- [blocks_file_source_0_1_0_0, '0', blocks_short_to_float_0_1_0_0, '0']
- [blocks_file_source_0_1_1, '0', blocks_short_to_float_0_1_1, '0']
- [blocks_file_source_0_1_1_0, '0', blocks_short_to_float_0_1_1_0, '0']
- [blocks_file_source_0_1_2, '0', blocks_short_to_float_0_1_2, '0']
- [blocks_file_source_0_1_2_0, '0', blocks_short_to_float_0_1_2_0, '0']
- [blocks_null_source_0, '0', pfb_synthesizer_ccf_0, '5']
- [blocks_short_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_short_to_float_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_short_to_float_0_1, '0', analog_frequency_modulator_fc_0_1, '0']
- [blocks_short_to_float_0_1_0, '0', analog_frequency_modulator_fc_0_1_0, '0']
- [blocks_short_to_float_0_1_0_0, '0', analog_frequency_modulator_fc_0_1_0_0, '0']
- [blocks_short_to_float_0_1_1, '0', analog_frequency_modulator_fc_0_1_1, '0']
- [blocks_short_to_float_0_1_1_0, '0', analog_frequency_modulator_fc_0_1_1_0, '0']
- [blocks_short_to_float_0_1_2, '0', analog_frequency_modulator_fc_0_1_2, '0']
- [blocks_short_to_float_0_1_2_0, '0', analog_frequency_modulator_fc_0_1_2_0, '0']
- [pfb_synthesizer_ccf_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_synthesizer_ccf_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_3, '0', pfb_synthesizer_ccf_0, '0']
- [rational_resampler_xxx_3_0, '0', pfb_synthesizer_ccf_0, '2']
- [rational_resampler_xxx_3_0_0, '0', pfb_synthesizer_ccf_0, '3']
- [rational_resampler_xxx_3_0_0_0, '0', pfb_synthesizer_ccf_0, '7']
- [rational_resampler_xxx_3_0_1, '0', pfb_synthesizer_ccf_0, '4']
- [rational_resampler_xxx_3_0_1_0, '0', pfb_synthesizer_ccf_0, '8']
- [rational_resampler_xxx_3_0_2, '0', pfb_synthesizer_ccf_0, '6']
- [rational_resampler_xxx_3_0_2_0, '0', pfb_synthesizer_ccf_0, '9']
- [rational_resampler_xxx_3_1, '0', pfb_synthesizer_ccf_0, '1']

metadata:
  file_format: 1
