options:
  parameters:
    author: rob
    generate_options: qt_gui
    id: M17_arn
    output_language: python
    title: M17 Amateur Radio Newsline
  states: {}

blocks:
- name: chan_spacing
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: deviation
  id: variable_qtgui_range
  parameters:
    label: Deviation
    rangeType: int
    start: '0'
    step: '10'
    stop: '2400'
    value: '800'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: '441490000'
    step: '100'
    stop: '441510000'
    value: '441504000'
  states: {}
- name: n_chans
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: This must be at least 512k for PlutoSDR
    value: symbol_rate * interpolation_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800.0'
  states: {}
- name: tx_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: analog_frequency_modulator_fc_0_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kb5mu/Desktop/ssf081_01-prefm.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/kb5mu/Desktop/ssf081_02.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/kb5mu/Desktop/ssf081_03.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '0.0'
    sample_rate: sample_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: 1 * chan_spacing
    sample_rate: sample_rate
  states: {}
- name: blocks_freqshift_cc_0_1
  id: blocks_freqshift_cc
  parameters:
    freq: '-1* chan_spacing'
    sample_rate: sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/n_chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/n_chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/n_chans
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '10000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lo_freq
    samplerate: tx_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: sample_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Frequency Modulation Data"'
    size: '1024'
    srate: sample_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    fbw: '0.4'
    interp: 'int((tx_rate * 3)/sample_rate) '
    type: ccc
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_frequency_modulator_fc_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_short_to_float_0_1, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_add_xx_0, '1']
- [blocks_freqshift_cc_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_freqshift_cc_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_freqshift_cc_0_1, '0']
- [blocks_short_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_short_to_float_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_short_to_float_0_1, '0', analog_frequency_modulator_fc_0_1, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
